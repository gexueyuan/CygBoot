# Keil uVision project project.uvproj, settings and files
target Cyg_Boot (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,
  c include: ..\library\STM32F4xx_StdPeriph_Driver\inc;..\library;..\include;..\library\Common;..\drives\fatfs\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../library/: stm32f4xx_it.c
    ../app/: cv_sys_main.c cv_app_upgrade.c cv_app_iap.c cv_app_sd.c
  group Drives
    ../drives/: flash_if.c ymodem.c cv_drives_flash.c cv_drives_sd_spi.c cv_drives_md5.c
  group Fatfs
    ../drives/fatfs/src/: diskio.c ff.c
    ../drives/fatfs/src/option/: ccsbcs.c
  group Bsp
    ../bsp/: cv_bsp_usart.c cv_bsp_gpio.c cv_bsp_timer.c cv_bsp_ckl.c
  group Library
    ../library/: system_stm32f4xx.c
    ../library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c stm32f4xx_dma2d.c
  group Startup
    ../startup/: startup_stm32f40xx.s
